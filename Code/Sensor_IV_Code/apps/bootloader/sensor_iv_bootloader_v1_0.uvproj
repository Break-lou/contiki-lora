# Keil uVision project sensor_iv_bootloader_v1_0.uvproj, settings and files
target sensor_iv_bootloader (ARM-ADS)
  device: SiM3L144 Silicon Labs
  cpu: IRAM(0x20001000-0x20003FFF) IRAM2(0x20000000-0x20000FFF) IROM(0x0-0x0FFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: sensor_iv_bootloader_v1_0 +hex
  AfterMake: fromelf.exe --bin -o @p.bin ./build/@p.axf
  c flags: Optim=1
  c define: NDEBUG
  c misc: --c99 --gnu
  c include: .;..\..\hal\drivers\si32Hal\CPU;..\..\hal\drivers\si32Hal\SI32_Modules;..\..\hal\drivers\si32Hal\sim3l1xx;.\arch;.\ext_flash;.\inchip_flash;.\boot;.\state;.\ext_flash
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\linker_sim3l1xx_arm.sct
  group SiM3xxxx
    ../../hal/drivers/si32Hal/CPU/: retarget_arm.c
    ../../hal/drivers/si32Hal/sim3l1xx/: startup_sim3l1xx_arm.s system_sim3l1xx.c
    ../../hal/drivers/si32Hal/SI32_Modules/: SI32_EXTOSC_A_Type.c SI32_PLL_A_Type.c SI32_RTC_B_Type.c SI32_SARADC_A_Type.c SI32_CMP_A_Type.c SI32_IDAC_A_Type.c SI32_PVTOSC_A_Type.c SI32_I2C_A_Type.c SI32_LCD_A_Type.c SI32_SPI_B_Type.c SI32_USART_B_Type.c SI32_UART_B_Type.c SI32_FLASHCTRL_A_Type.c SI32_DCDC_A_Type.c SI32_VMON_B_Type.c SI32_VREF_B_Type.c SI32_LPTIMER_B_Type.c SI32_EPCA_A_Type.c SI32_EPCACH_A_Type.c SI32_TIMER_A_Type.c SI32_WDTIMER_A_Type.c SI32_AES_B_Type.c SI32_ECRC_A_Type.c SI32_ENCDEC_A_Type.c SI32_ACCTR_A_Type.c
  group SIM3L1XX
    ../../hal/drivers/si32Hal/sim3l1xx/: SI32_PMU_A_Type.c SI32_LDO_A_Type.c SI32_LOCK_A_Type.c SI32_RSTSRC_A_Type.c
  group sensor_iv_bootloader_v1_0
    ./: main.c
  group arch
    ./arch/: system_init.c
  group ext_flash
    ./ext_flash/: ext_flash_hal.c ext_flash_mcu.c ext_flash_tat.c
  group inchip_flash
    ./inchip_flash/: inchip_flash.c
  group boot
    ./boot/: boot.c crc.c
  group state
    ./state/: state.c
