# Keil uVision project SensorIVPro.uvproj, settings and files
target sensor (ARM-ADS)
  device: SiM3L144 Silicon Labs
  cpu: IRAM(0x20001000-0x20003FFF) IRAM2(0x20000000-0x20000FFF) IROM(0x0-0x0FFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: SensorIVPro +hex
  AfterMake: fromelf.exe --bin -o @p.bin ./build/@p.axf
  c flags: Optim=1
  c define: NDEBUG
  c misc: --c99 --gnu
  c include: ..\..\..\hal\drivers\si32Hal\sim3l1xx;..\..\..\hal\drivers\si32Hal\CPU;..\..\..\hal\drivers\si32Hal\SI32_Modules;..\..\..\hal\generic\si32\inc;..\inc;..\..\..\core\lib;..\..\..\core\sys;..\..\..\core;..\..\..\common;..\..\..\cpu\si32;..\..\..\modules\flash;..\..\..\process\sensor;..\..\..\process\system;..\..\..\common\simulate_i2c;..\..\..\process\sensor;..\..\..\modules\sensor;..\..\..\process\sensor;..\..\..\modules\rf\sx127x;..\..\..\protocol;..\..\..\common\AT;..\..\..\bootloader
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\hal\drivers\si32Hal\sim3l1xx\linker_sim3l1xx_arm.sct
  group apps
    ../inc/: board_cfg.h
    ../src/: main.c si32_system_it.c si32_system_init.c dio_handler.c power_manager.c
  group core
    ../../../core/sys/: autostart.c etimer.c process.c timer.c
  group cpu
    ../../../cpu/si32/: clock.c debug-uart.c
  group common
    ../../../common/: delay.c crc.c debug_util.c data_conversion.c software_version.c timestamp.c
    ../../../common/simulate_i2c/: simulate_i2c.c
  group protocol
    ../../../protocol/: sensor_sixteen.c sensor_payload.c sensor_parameter.c
  group modules/rf/sx127x
    ../../../modules/rf/sx127x/: sx127x_app.c sx127x_hal.c sx127x_radio.c
  group modules/flash
    ../../../modules/flash/: ext_flash_hal.c ext_flash_mcu.c ext_flash_storage.c ext_flash_storage_debug.c ext_flash_tat.c download_history.c broadcast_program.c
  group modules/sensor
    ../../../modules/sensor/: battery.c water_power.c nhzf42.c ds18b20.c ds18b20_bus.c soil_moisture.c nhzd10.c illumi.c nhfs15.c aca826t.c sca126t.c nhuv11.c mlx90614.c skd_100d.c lvdt.c rotonic.c
  group process/system
    ../../../process/system/: sys_event.h system_process_include.h key_process.c led_process.c analysis_process.c cycle_work_process.c sen_work_process.c data_download_process.c quick_work_process.c rf_transmit_process.c
  group process/sensor
    ../../../process/sensor/: sensor_process_include.h sensor_manager_process.c sensor_water_power.c sensor_nhzf42_process.c sensor_ds18b20_process.c sensor_soil_moisture_process.c sensor_illumi_process.c sensor_nhfs15_process.c sensor_5tm_process.c sensor_aca826t_process.c sensor_sca126t_process.c sensor_nhzd10_process.c sensor_modbus_process.c sensor_nhuv11_process.c sensor_mlx90614_process.c sensor_skd_100d_process.c sensor_lvdt_process.c sensor_rotonic_process.c
  group hal/generic/si32/src
    ../../../hal/generic/si32/src/: rtc_config.c clock_config.c pmatch_config.c pmu_config.c port_config.c spi_config.c wdtimer_config.c LED.c internal_adc.c internal_adc_option.c flash_config.c serial.c uart.c usart.c sdi12.c sdi12_operation.c modbus.c
    ../../../hal/generic/si32/inc/: generic_include.h
  group hal/drivers/si32Hal/sim3l1xx
    ../../../hal/drivers/si32Hal/sim3l1xx/: SI32_PMU_A_Type.c SI32_LDO_A_Type.c SI32_LOCK_A_Type.c SI32_RSTSRC_A_Type.c
  group hal/drivers/si32Hal/SI32_Modules
    ../../../hal/drivers/si32Hal/CPU/: retarget_arm.c
    ../../../hal/drivers/si32Hal/sim3l1xx/: startup_sim3l1xx_arm.s system_sim3l1xx.c
    ../../../hal/drivers/si32Hal/SI32_Modules/: SI32_EXTOSC_A_Type.c SI32_PLL_A_Type.c SI32_RTC_B_Type.c SI32_SARADC_A_Type.c SI32_CMP_A_Type.c SI32_IDAC_A_Type.c SI32_PVTOSC_A_Type.c SI32_I2C_A_Type.c SI32_SPI_B_Type.c SI32_USART_B_Type.c SI32_UART_B_Type.c SI32_FLASHCTRL_A_Type.c SI32_DCDC_A_Type.c SI32_VMON_B_Type.c SI32_VREF_B_Type.c SI32_LPTIMER_B_Type.c SI32_EPCA_A_Type.c SI32_TIMER_A_Type.c SI32_WDTIMER_A_Type.c SI32_AES_B_Type.c SI32_ECRC_A_Type.c SI32_ENCDEC_A_Type.c SI32_ACCTR_A_Type.c
  group AT
    ../../../common/AT/: AT_OPERATION.c AT_CMD.c
  group bootloader
    ../../../bootloader/: sensor_iv_boot.c
  group note
    ../src/: ReadMe.txt
